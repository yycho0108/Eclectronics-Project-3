File: ultrasonic_localization/ultrasonic_localization.sch (KiCad schematic (older format))
At the start: 30 parts, among them J1 USB_OTG_fix, J2 Conn_02x03_Odd_Even, Q1 BUK9Y29-40E, SW1 SW_Push, SW2 SW_DPDT, SW3 SW_DPDT, U1 ATMEGA32U4RC-AU, U3 MD0105, U5 4047, Y1 16MHz

Commit message: Routed rotational module
Parts:
- renumbered C1 to C101, C2 to C102, C3 to C103, C4 to C104, C5 to C105, C7 to C106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
