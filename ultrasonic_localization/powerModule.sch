File: ultrasonic_localization/powerModule.sch (KiCad schematic (older format))
At the start: 35 parts, among them J3 Screw_Terminal_1x02_Bat, U10 AP3012, U11 AP3012, U12 TPS6223x, U13 LP5907SNX-3.3/NOPB, U14 BQ2423

Commit message: Routed rotational module
Parts:
- renumbered C25 to C401, C26 to C402, C27 to C403, C28 to C404, C29 to C405, C30 to C406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
