# Repository yycho0108/Eclectronics-Project-3

File README.md:

# Eclectronics-Project-3
Project 3 : Indoor Localization System for ENGR3430: Eclectronics

## KiCad design ultrasonic_localization/ultrasonic_localization.kicad_pcb

Parts:
C101: 10uF; C_0805
C102, C103: 12pF; C_0603
C104, C105: 1uF; C_0603
C106: 10nF; C_0603
Cp101, Cp102, Cp103, Cp104, Cp105: 0.1uF; C_0603
D101: LED; LED_0805
J101: USB_OTG_fix; USB_microB_2040002-1_alt
J102: Conn_02x03_Odd_Even; Socket_Strip_Straight_2x03_Pitch2.54mm
Q101: BUK9Y29-40E; SOT-669_LFPAK
R101, R102: 20; R_0603
R103, R104, R107, R108: 10K; R_0603
R105: 604; R_0603
R106: 9.53K; R_0603
SW101: SW_Push; SW_SPST_B3S-1000
SW102, SW103: SW_DPDT; JS202011SCQN
U101: ATMEGA32U4RC-AU; TQFP-44-1EP_10x10mm_Pitch0.8mm
U103: 4047; SOIC-14_3.9x8.7mm_Pitch1.27mm
U104: ADG5434; TSSOP-20_4.4x6.5mm_Pitch0.65mm
Y101: Crystal_GND24; Crystal_SMD_3225-4pin_3.2x2.5mm

Connections:
+5V: C101.1, Cp101.1, Cp102.1, Cp103.1, Cp104.1, Cp105.1, J102.2, R103.2, SW102.3 (C), U101.2 (UVCC), U101.14 (VCC), U101.24 (AVCC), U101.34 (VCC), U101.44 (AVCC), U103.4 (~ASTABLE), U103.5 (ASTABLE), U103.6 (-TRIGGER), U103.14 (VDD); also elsewhere on the board
/+26V: Q101.3 (S), U104.16 (VDD); also elsewhere on the board
/D2: U101.20 ((RXD/INT2)PD2); also elsewhere on the board
/D3: U101.21 ((TXD/INT3)PD3); also elsewhere on the board
/ID: R104.1, SW102.2 (B), U101.1 ((INT6/AIN0)PE6)
/IRQ: U101.40 ((ADC1)PF1); also elsewhere on the board
/MISO: J102.1, U101.11 ((PDO/MISO/PCINT3)PB3); also elsewhere on the board
/MOSI: J102.4, U101.10 ((PDI/MOSI/PCINT2)PB2); also elsewhere on the board
/OSC_IC: R108.1, SW103.1 (A), U103.13 (OSC_OUT)
/OSC_MCU: SW103.3 (C), U101.29 ((ADC12/OC1A/~OC4B~/PCINT12)PB5)
/RESET: J102.5, R103.1, SW101.2, U101.13 (~RESET~)
/RF_CE: U101.41 ((ADC0)PF0); also elsewhere on the board
/RX1: U104.4 (S1B); also elsewhere on the board
/RX2: U104.7 (S2B); also elsewhere on the board
/RX3: U104.14 (S3B); also elsewhere on the board
/RX4: U104.17 (S4B); also elsewhere on the board
/SCK: J102.3, U101.9 ((SCLK/PCINT1)PB1); also elsewhere on the board
/SCL: U101.18 ((OC0B/SCL/INT0)PD0); also elsewhere on the board
/SDA: U101.19 ((SDA/INT1)PD1); also elsewhere on the board
/SIG1: U101.25 ((ICP2/ADC8)PD4); also elsewhere on the board
/SIG2: U101.22 ((XCK1/~CTS~)PD5); also elsewhere on the board
/SIG3: U101.26 ((T1/~OC4D~/ADC9)PD6); also elsewhere on the board
/SIG4: U101.27 ((T0/OC4D/ADC10)PD7); also elsewhere on the board
/SS: U101.8 ((SS/PCINT0)PB0); also elsewhere on the board
/THRESH: U101.12 ((OC0A/OC1C/~RTS~/PCINT7)PB7); also elsewhere on the board
/TX: Q101.5 (D), U104.2 (S1A), U104.9 (S2A), U104.12 (S3A), U104.19 (S4A)
/TX_EN: U101.30 ((ADC13/OC1B/OC4B/PCINT13)PB6), U104.1 (IN1), U104.10 (IN2), U104.11 (IN3), U104.20 (IN4)
/USB5V: J101.1 (VBUS), U101.7 (VBUS); also elsewhere on the board
/UX1: U104.3 (D1); also elsewhere on the board
/UX2: U104.8 (D2); also elsewhere on the board
/UX3: U104.13 (D3); also elsewhere on the board
/UX4: U104.18 (D4); also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.1, C105.1, Cp101.2, Cp102.2, Cp103.2, Cp104.2, Cp105.2, D101.1 (K), J101.5 (GND), J101.6 (Shield), J102.6, R104.2, R107.2, SW101.1, SW102.1 (A), U101.5 (UGND), U101.15 (GND), U101.23 (GND), U101.33 ((~HWB~)PE2), U101.35 (GND), U101.43 (GND), U103.7 (VSS), U103.8 (+TRIGGER), U103.12 (RETRIGGER), U104.5 (VSS), U104.6 (GND), Y101.2, Y101.4; also elsewhere on the board
unnamed: C102.1, U101.17 (XTAL1), Y101.1
unnamed: C103.1, U101.16 (XTAL2), Y101.3
unnamed: C104.2, U101.6 (UCAP)
unnamed: C105.2, U101.42 (AREF)
unnamed: C106.1, U103.1 (C)
unnamed: C106.2, R105.1, R106.1, U103.3 (RC_COMMON)
unnamed: D101.2 (A), R108.2
unnamed: J101.2 (D-), R102.2
unnamed: J101.3 (D+), R101.1
unnamed: Q101.1 (S), Q101.2 (S)
unnamed: Q101.4 (G), SW103.2 (B)
unnamed: R101.2, U101.4 (D+)
unnamed: R102.1, U101.3 (D-)
unnamed: R105.2, R106.2, U103.2 (R)
unnamed: R107.1, U103.9 (EXT_RESET)

Notes on the sheet:
Power & Bypass Capacitors
Ultrasonic Transceivers
(encloses BAT)
Module ID
TODO : CHECK DIGITAL SIG & Pin Assignments
ICSP HEADER

Parts:
C201: 10nF; C_0603
C202: 1nF; C_0603
C203: 33nF; C_0603
C204, C205: 12pF; C_0603
C206: 2.2nF; C_0603
C207: 4.7pF; C_0603
C208: 1.5pF; C_0603
C209: 1pF; C_0603
L201: 8.2nH; L_0603
L202: 3.9nH; L_0603
L203: 2.7nH; L_0603
R201: 1M; R_0603
R202: 20K; R_0603
U201: nRF24L01+; QFN-20-1EP_4x4mm_Pitch0.5mm
U202: ANT016008LCS2442MA2
Y201: 16MHz; Crystal_SMD_3225-4pin_3.2x2.5mm

Connections:
+3V3: C201.1, C202.1, U201.7 (VDD), U201.15 (VDD), U201.18 (VDD); also elsewhere on the board
/IRQ: U201.6 (~IRQ); also elsewhere on the board
/MISO: U201.5 (MISO); also elsewhere on the board
/MOSI: U201.4 (MOSI); also elsewhere on the board
/RF Module/RF: U202.1 (OUT)
/RF_CE: U201.1 (CE); also elsewhere on the board
/SCK: U201.3 (SCK); also elsewhere on the board
/SS: U201.2 (CSN); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C209.2, R202.1, U201.8 (VSS), U201.14 (VSS), U201.17 (VSS), U201.20 (VSS), Y201.2, Y201.4; also elsewhere on the board
unnamed: C203.1, U201.19 (DVDD)
unnamed: C204.1, R201.2, U201.9 (XC2), Y201.1
unnamed: C205.1, R201.1, U201.10 (XC1), Y201.3
unnamed: C206.1, C207.1, L203.1, U201.11 (VDD_PA)
unnamed: C208.1, C209.1, U202.4 (IN)
unnamed: C208.2, L202.1
unnamed: L201.1, L202.2, U201.13 (ANT2)
unnamed: L201.2, L203.2, U201.12 (ANT1)
unnamed: R202.2, U201.16 (IREF)

Parts:
C501: 150nF; C_0603
C502: 1uF; C_0603
C503, C507, C508: 10nF; C_0603
C504, C505: 1nF; C_0603
C506: 12pF; C_0603
D501, D502: BAS16GWJ; D_SOD-123
Q501: BC847; SOT-23
R501, R502, R506: 1K; R_0603
R503, R508, R514, R516: 10K; R_0603
R504: 62K; R_0603
R505: 665; R_0603
R507: 40.2K; R_0603
R509: 3.3M; R_0603
R510, R515: 120K; R_0603
R511, R512: 75K; R_0603
R513: 4.53K; R_0603
R517: 3.9K; R_0603
U501: LM324; SOIC-14_3.9x8.7mm_Pitch1.27mm
U502: TCT40-16R/T; TCT40-16R_T

Connections:
+5V: R501.2, R514.1, U501.4 (V+); also elsewhere on the board
/RX1: D501.1 (K), D502.2 (A), R503.2; also elsewhere on the board
/SIG1: Q501.3 (C), R514.2, R515.1; also elsewhere on the board
/Sound Module/VGND: C501.2, C502.2, R501.1, R502.2, R506.2, R510.1, U501.3 (+), U501.5 (+), U501.10 (+)
/THRESH: R511.2; also elsewhere on the board
/UX1: U502.1; also elsewhere on the board
GND: C501.1, C502.1, C508.2, D501.2 (A), D502.1 (K), Q501.2 (E), R502.1, R509.2, R517.2, U501.11 (V-), U502.2; also elsewhere on the board
unnamed: C503.1, R503.1
unnamed: C503.2, R504.2, U501.2 (-)
unnamed: C504.1, C505.1, R505.1, R506.1
unnamed: C504.2, C506.2, R507.2, R508.1, U501.7
unnamed: C505.2, C506.1, R507.1, U501.6 (-)
unnamed: C507.1, R508.2
unnamed: C507.2, R512.1, U501.9 (-)
unnamed: C508.1, R509.1, R510.2, R511.1, U501.13 (-)
unnamed: Q501.1 (B), R516.2, R517.1
unnamed: R504.1, R505.2, U501.1
unnamed: R512.2, R513.2, U501.8
unnamed: R513.1, R515.2, U501.12 (+)
unnamed: R516.1, U501.14

Parts of its further copies:
C301, C601, C701: 150nF; C_0603
C302, C602, C702: 1uF; C_0603
C303, C307, C308, C603, C607, C608, C703, C707, C708: 10nF; C_0603
C304, C305, C604, C605, C704, C705: 1nF; C_0603
C306, C606, C706: 12pF; C_0603
D301, D302, D601, D602, D701, D702: BAS16GWJ; D_SOD-123
Q301, Q601, Q701: BC847; SOT-23
R301, R302, R306, R601, R602, R606, R701, R702, R706: 1K; R_0603
R303, R308, R314, R316, R603, R608, R614, R616, R703, R708, R714, R716: 10K; R_0603
R304, R604, R704: 62K; R_0603
R305, R605, R705: 665; R_0603
R307, R607, R707: 40.2K; R_0603
R309, R609, R709: 3.3M; R_0603
R310, R315, R610, R615, R710, R715: 120K; R_0603
R311, R312, R611, R612, R711, R712: 75K; R_0603
R313, R613, R713: 4.53K; R_0603
R317, R617, R717: 3.9K; R_0603
U301, U601, U701: LM324; SOIC-14_3.9x8.7mm_Pitch1.27mm
U302, U602, U702: TCT40-16R/T; TCT40-16R_T

Connections of its further copies:
+5V: R301.2, R314.1, R601.2, R614.1, R701.2, R714.1, U301.4 (V+), U601.4 (V+), U701.4 (V+); also elsewhere on the board
/RX2: D301.1 (K), D302.2 (A), R303.2; also elsewhere on the board
/RX3: D601.1 (K), D602.2 (A), R603.2; also elsewhere on the board
/RX4: D701.1 (K), D702.2 (A), R703.2; also elsewhere on the board
/SIG2: Q301.3 (C), R314.2, R315.1; also elsewhere on the board
/SIG3: Q601.3 (C), R614.2, R615.1; also elsewhere on the board
/SIG4: Q701.3 (C), R714.2, R715.1; also elsewhere on the board
/Sound Module 2/VGND: C301.2, C302.2, R301.1, R302.2, R306.2, R310.1, U301.3 (+), U301.5 (+), U301.10 (+)
/Sound Module 3/VGND: C601.2, C602.2, R601.1, R602.2, R606.2, R610.1, U601.3 (+), U601.5 (+), U601.10 (+)
/Sound Module 4/VGND: C701.2, C702.2, R701.1, R702.2, R706.2, R710.1, U701.3 (+), U701.5 (+), U701.10 (+)
/THRESH: R311.2, R611.2, R711.2; also elsewhere on the board
/UX2: U302.1; also elsewhere on the board
/UX3: U602.1; also elsewhere on the board
/UX4: U702.1; also elsewhere on the board
GND: C301.1, C302.1, C308.2, C601.1, C602.1, C608.2, C701.1, C702.1, C708.2, D301.2 (A), D302.1 (K), D601.2 (A), D602.1 (K), D701.2 (A), D702.1 (K), Q301.2 (E), Q601.2 (E), Q701.2 (E), R302.1, R309.2, R317.2, R602.1, R609.2, R617.2, R702.1, R709.2, R717.2, U301.11 (V-), U302.2, U601.11 (V-), U602.2, U701.11 (V-), U702.2; also elsewhere on the board
unnamed: C303.1, R303.1
unnamed: C303.2, R304.2, U301.2 (-)
unnamed: C304.1, C305.1, R305.1, R306.1
unnamed: C304.2, C306.2, R307.2, R308.1, U301.7
unnamed: C305.2, C306.1, R307.1, U301.6 (-)
unnamed: C307.1, R308.2
unnamed: C307.2, R312.1, U301.9 (-)
unnamed: C308.1, R309.1, R310.2, R311.1, U301.13 (-)
unnamed: C603.1, R603.1
unnamed: C603.2, R604.2, U601.2 (-)
unnamed: C604.1, C605.1, R605.1, R606.1
unnamed: C604.2, C606.2, R607.2, R608.1, U601.7
unnamed: C605.2, C606.1, R607.1, U601.6 (-)
unnamed: C607.1, R608.2
unnamed: C607.2, R612.1, U601.9 (-)
unnamed: C608.1, R609.1, R610.2, R611.1, U601.13 (-)
unnamed: C703.1, R703.1
unnamed: C703.2, R704.2, U701.2 (-)
unnamed: C704.1, C705.1, R705.1, R706.1
unnamed: C704.2, C706.2, R707.2, R708.1, U701.7
unnamed: C705.2, C706.1, R707.1, U701.6 (-)
unnamed: C707.1, R708.2
unnamed: C707.2, R712.1, U701.9 (-)
unnamed: C708.1, R709.1, R710.2, R711.1, U701.13 (-)
unnamed: Q301.1 (B), R316.2, R317.1
unnamed: Q601.1 (B), R616.2, R617.1
unnamed: Q701.1 (B), R716.2, R717.1
unnamed: R304.1, R305.2, U301.1
unnamed: R312.2, R313.2, U301.8
unnamed: R313.1, R315.2, U301.12 (+)
unnamed: R316.1, U301.14
unnamed: R604.1, R605.2, U601.1
unnamed: R612.2, R613.2, U601.8
unnamed: R613.1, R615.2, U601.12 (+)
unnamed: R616.1, U601.14
unnamed: R704.1, R705.2, U701.1
unnamed: R712.2, R713.2, U701.8
unnamed: R713.1, R715.2, U701.12 (+)
unnamed: R716.1, U701.14

Parts:
C401, C409, C411: 10uF; C_0805
C402, C403: 1uf; C_0603
C404, C405, C407, C408, C410: 1uF; C_0603
C406: 4.7uF; C_0603
D401, D402: 1N5819; D_SOD-123
D403, D404: LED; LED_0805
J401: Screw_Terminal_1x02_Bat; 1x2_Screw_Terminal_5mm_pitch
L401, L402: 10uH; L_0603
L403: 2.2uH; L_0603
R401: 3.01K; R_0603
R402, R404: 1K; R_0603
R403: 20K; R_0603
R405: 10K; R_0603
R406: 3.57K; R_0603
R407, R409: 1.5K; R_0603
R408: 2.94K; R_0603
R410: 4.32K; R_0603
R411: 56.2K; R_0603
U401, U402: AP3012; SOT-23-5
U403: TPS6223x; UFDFN-6-1.5x1.05mm_Pitch0.5mm
U404: LP5907SNX-3.3/NOPB; SOT-23-5
U405: BQ2423; QFN-16-1EP_3x3mm_Pitch0.5mm_ThermalVias

Connections:
+1V8: C408.1, U404.5 (OUT); also elsewhere on the board
+3V3: C406.1, L403.1, U403.6 (FB); also elsewhere on the board
+5V: C404.1, D401.1 (K), R401.1; also elsewhere on the board
/+26V: C405.1, D402.1 (K), R403.1; also elsewhere on the board
/Power/3V7: C401.1, C402.1, C403.1, C407.1, C411.2, L401.2, L402.2, R407.1, R409.1, U401.4 (SHDN), U401.5 (VIN), U402.4 (SHDN), U402.5 (VIN), U403.3 (VIN), U403.5 (EN), U404.1 (IN), U404.3 (EN), U405.5 (EN2), U405.10 (OUT), U405.11 (OUT)
/USB5V: C410.1, U405.13 (IN); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.1, J401.2, R402.2, R404.2, R405.1, R406.2, R408.2, R410.2, R411.2, U401.2 (GND), U402.2 (GND), U403.1 (MODE), U403.4 (GND), U404.2 (GND), U405.4 (~CE), U405.6 (EN1), U405.8 (VSS); also elsewhere on the board
unnamed: C409.1, J401.1, U405.2 (BAT), U405.3 (BAT)
unnamed: D401.2 (A), L401.1, U401.1 (SW)
unnamed: D402.2 (A), L402.1, U402.1 (SW)
unnamed: D403.1 (K), U405.7 (~PGOOD)
unnamed: D403.2 (A), R407.2
unnamed: D404.1 (K), U405.9 (~CHG)
unnamed: D404.2 (A), R409.2
unnamed: L403.2, U403.2 (SW)
unnamed: R401.2, R402.1, U401.3 (FB)
unnamed: R403.2, R404.1, U402.3 (FB)
unnamed: R405.2, U405.1 (TS)
unnamed: R406.1, U405.15 (ITERM)
unnamed: R408.1, U405.12 (ILIM)
unnamed: R410.1, U405.16 (ISET)
unnamed: R411.1, U405.14 (TMR)

Notes on the sheet:
Battery Management
3V3 Regulator
Boost Converter, 5V
Boost Converter, 26V
1V8 Regulator

Parts:
C801: 100nF; C_0603
R801, R802, R803, R804, R805, R806, R807: 10K; R_0603
U801: IMU; Bosch_LGA-14_3x2.5mm_Pitch0.5mm
U802: Level_Shifter_4Channel; TSSOP-14_4.4x5mm_Pitch0.65mm

Connections:
+1V8: C801.1, R801.2, R802.2, R803.2, U801.5 (VDDIO), U801.8 (VDD), U802.1 (Vref_A); also elsewhere on the board
+5V: R806.2, R807.2, U802.11 (Vref_B), U802.12 (EN); also elsewhere on the board
/D2: R804.1, U802.7 (B4); also elsewhere on the board
/D3: R805.1, U802.8 (B3); also elsewhere on the board
/IMU Module/INT1_1V8: U801.4 (INT1), U802.5 (A4)
/IMU Module/INT2_1V8: U801.9 (INT2), U802.4 (A3)
/IMU Module/SCL_1V8: R802.1, U801.13 (SCL), U802.3 (A2)
/IMU Module/SDA_1V8: R803.1, U801.14 (SDA), U802.2 (A1)
/SCL: R807.1, U802.10 (B1); also elsewhere on the board
/SDA: R806.1, U802.9 (B2); also elsewhere on the board
GND: C801.2, R804.2, R805.2, U801.2 (SDx), U801.3 (SCx), U801.6 (GND), U801.7 (GND), U802.6 (GND); also elsewhere on the board
unnamed: R801.1, U801.1 (SDO/SA0), U801.12 (CS)

Board: 2 copper layers, 69.6 x 80.4 mm, 212 parts (0 on the bottom side), 136 nets.

## Commit log

2017-10-25 added gitignore
2017-10-28 preliminary layout
2017-10-30 updated and created some schematic components
2017-10-30 updated oscillator connections
2017-11-01 Made a power switching module work
2017-11-01 adding more cxns
2017-11-02 Added sheet
2017-11-02 changed main sheet
2017-11-02 Did some stuff with power
2017-11-02 adding sound module stuffs
2017-11-02 ultrasonic figured out
2017-11-02 Did RF module
2017-11-02 organization
2017-11-02 refactoring some stuff
2017-11-02 refactored power
2017-11-02 Added a antenna
2017-11-02 schematic review version
2017-11-03 added mosfet
2017-11-03 Changed stuff
2017-11-03 finished ultrasound and some other stuff
2017-11-06 added osc src
2017-11-06 Added IMU
2017-11-06 Added ICSP header
2017-11-06 sim + analysis for 40kHz filter
2017-11-06 pushing stuff
2017-11-06 IMU pulldown
2017-11-09 Fixed garbage
2017-11-09 Assigned many footprints to things
2017-11-09 almost resolved DRC
2017-11-11 Assigned footprints to menial components
2017-11-11 all associated
2017-11-16 THRESH analysis
2017-11-16 Routed rotational module
2017-11-16 fixed symbols, some connections, and laid out submodules
2017-11-16 Routed most of the board
2017-11-16 Finished routing
2017-11-16 Made all of the text nice
2017-11-16 made pretty colors
2017-11-17 added mux
2017-11-17 finished routing with the new mux
2017-11-26 Fixed board
2017-11-27 Converting BoM to useful CSV
2017-12-01 figs
2017-12-01 stuff
